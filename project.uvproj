# Keil uVision project project.uvproj, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Nuvoton_ARM9_Series Nuvoton
  cpu: IRAM(0x0-0x0) CLOCK(000000000) CPUTYPE(ARM926EJ-S)
  output: rtthread
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --c99
  c include: packages\LVGL-v8.3.5\src\extra\libs\qrcode;libraries\n9h30\Driver\Include;rt-thread\components\net\sal\include\socket;packages\LVGL-v8.3.5\src\extra\layouts\flex;libraries\nu_packages\AudioCodec;packages\LVGL-v8.3.5\src\extra\libs\bmp;libraries\nu_packages\ADC_TOUCH;packages\LVGL-v8.3.5\src\extra\libs\sjpg;.;packages\LVGL-v8.3.5\src\extra\widgets\meter;packages\LVGL-v8.3.5\src\draw\swm341_dma2d;packages\LVGL-v8.3.5\src\extra\widgets\keyboard;packages\LVGL-v8.3.5\src\extra\widgets\tabview;packages\LVGL-v8.3.5\src\extra\others\monkey;packages\LVGL-v8.3.5\src\extra\themes;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\LVGL-v8.3.5\src\extra\libs;packages\LVGL-v8.3.5\src\extra\widgets\spinbox;packages\LVGL-v8.3.5\src\extra\widgets\imgbtn;packages\LVGL-v8.3.5\src\extra\layouts\grid;libraries\n9h30\rtt_port;rt-thread\components\net\lwip\port;packages\LVGL-v8.3.5\src\extra\widgets\msgbox;packages\LVGL-v8.3.5\src\extra\widgets\list;rt-thread\components\drivers\include;rt-thread\components\drivers\include;packages\LVGL-v8.3.5\src\widgets;packages\LVGL-v8.3.5\src\extra\libs\rlottie;packages\LVGL-v8.3.5\src\draw\arm2d;packages\LVGL-v8.3.5\demos\music\assets;rt-thread\components\drivers\include;rt-thread\components\utilities\utest;rt-thread\components\libc\compilers\common\extension;rt-thread\components\drivers\include;packages\LVGL-v8.3.5\src\extra\others\msg;packages\LVGL-v8.3.5\demos\benchmark;packages\LVGL-v8.3.5\src\extra\others\gridnav;rt-thread\include;packages\LVGL-v8.3.5\src\extra\widgets\span;rt-thread\components\libc\posix\io\poll;packages\LVGL-v8.3.5\demos\music;packages\LVGL-v8.3.5\src\extra\widgets\tileview;packages\LVGL-v8.3.5\src\hal;packages\CherryUSB\osal;rt-thread\components\dfs\include;packages\CherryUSB\class\msc;applications\lvgl;packages\LVGL-v8.3.5\src\extra\widgets\spinner;packages\LVGL-v8.3.5\src\extra\libs\freetype;packages\LVGL-v8.3.5\src\extra\others\fragment;rt-thread\components\net\sal\include\dfs_net;packages\ramdisk-latest\inc;rt-thread\components\net\lwip\lwip-2.1.2\src\include\netif;packages\CherryUSB\class\hub;rt-thread\components\drivers\audio;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;packages\LVGL-v8.3.5\src\extra\libs\ffmpeg;packages\LVGL-v8.3.5\src\draw\nxp\pxp;rt-thread\components\drivers\touch;packages\LVGL-v8.3.5\src\extra\widgets\led;libraries\nu_packages\NuUtils\inc;rt-thread\components\drivers\include;rt-thread\libcpu\arm\common;packages\LVGL-v8.3.5\src\extra\others\snapshot;rt-thread\components\net\sal\impl;packages\LVGL-v8.3.5\src\extra\libs\png;rt-thread\components\drivers\include;rt-thread\components\dfs\filesystems\devfs;packages\LVGL-v8.3.5\src\draw\nxp\vglite;rt-thread\components\drivers\spi;packages\LVGL-v8.3.5\src\draw;rt-thread\components\net\sal\include\socket\sys_socket;packages\LVGL-v8.3.5\src\extra\others;rt-thread\components\net\netdev\include;packages\LVGL-v8.3.5\src\extra\themes\basic;rt-thread\components\libc\compilers\common\include;packages\LVGL-v8.3.5\src\draw\sdl;packages\LVGL-v8.3.5\demos;packages\CherryUSB\class\dfu;packages\LVGL-v8.3.5\src\extra\others\imgfont;rt-thread\components\drivers\include;rt-thread\components\net\sal\include;packages\LVGL-v8.3.5\src\extra\libs\fsdrv;packages\CherryUSB\core;packages\LVGL-v8.3.5\src\extra\layouts;rt-thread\components\fal\inc;packages\CherryUSB\common;rt-thread\libcpu\arm\arm926;packages\CherryUSB\class\video;packages\LVGL-v8.3.5\src\extra\widgets\animimg;packages\LVGL-v8.3.5\src\draw\sw;packages\CherryUSB\class\cdc;rt-thread\components\drivers\include;packages\LVGL-v8.3.5\src\misc;packages\LVGL-v8.3.5\src\extra\widgets\win;packages\LVGL-v8.3.5\src\extra\widgets\calendar;packages\LVGL-v8.3.5\demos\keypad_encoder;packages\LVGL-v8.3.5\demos\widgets;packages\LVGL-v8.3.5\src\extra;rt-thread\components\drivers\include;rt-thread\components\finsh;packages\LVGL-v8.3.5\src\extra\widgets\chart;packages\LVGL-v8.3.5\src\extra\themes\default;packages\LVGL-v8.3.5\src\extra\themes\mono;packages\CherryUSB\class\hid;packages\LVGL-v8.3.5\src\extra\widgets;packages\LVGL-v8.3.5\src\extra\widgets\menu;rt-thread\components\libc\posix\ipc;packages\LVGL-v8.3.5\src\font;packages\LVGL-v8.3.5\demos\stress;libraries\n9h30\rtt_port\cherryusb;packages\CherryUSB\class\audio;board;rt-thread\components\libc\posix\io\stdio;packages\CherryUSB\class\wireless;packages\LVGL-v8.3.5\src\extra\widgets\colorwheel;rt-thread\components\drivers\include;packages\LVGL-v8.3.5\src\core;packages\LVGL-v8.3.5\src\extra\others\ime;packages\LVGL-v8.3.5\env_support\rt-thread;packages\LVGL-v8.3.5\src\extra\libs\gif;rt-thread\components\net\lwip\lwip-2.1.2\src\include;rt-thread\components\dfs\filesystems\elmfat;packages\LVGL-v8.3.5\src;applications;packages\LVGL-v8.3.5\src\draw\stm32_dma2d
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: .\linking_scripts\n9h30.sct
  group Applications
    applications/: main.c mnt.c
  group board
    board/: nu_pin_init.c board_dev.c
  group CherryUSB
    packages/CherryUSB/class/hid/: usbh_hid.c
    packages/CherryUSB/class/cdc/: usbh_cdc_acm.c
    packages/CherryUSB/osal/: usb_osal_rtthread.c
    packages/CherryUSB/third_party/rt-thread-4.1.1/rndis_host/: rndis_host.c
    packages/CherryUSB/demo/: usb_host.c
    packages/CherryUSB/class/msc/: usbh_msc.c
    packages/CherryUSB/class/wireless/: usbh_rndis.c
    packages/CherryUSB/third_party/rt-thread-4.1.1/dfs/: udisk.c
    packages/CherryUSB/class/hub/: usbh_hub.c
    packages/CherryUSB/third_party/rt-thread-4.1.1/: msh_cmd.c
    packages/CherryUSB/port/ehci/: usb_hc_ehci.c
    packages/CherryUSB/core/: usbh_core.c
  group CherryUSB-port
    libraries/n9h30/rtt_port/cherryusb/: drv_cherryusb.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/arm926/: context_rvds.S cpuport.c machine.c mmu.c stack.c start_rvds.S trap.c
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    rt-thread/components/drivers/audio/: audio.c audio_pipe.c
    rt-thread/components/drivers/can/: can.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c pin.c rt_drv_pwm.c rt_inputcapture.c
    rt-thread/components/drivers/mtd/: mtd_nand.c
    rt-thread/components/drivers/rtc/: alarm.c rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: qspi_core.c spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/touch/: touch.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    libraries/n9h30/rtt_port/: drv_etimer.c drv_systick.c drv_adc.c drv_can.c drv_i2s.c drv_common.c drv_rtc.c drv_qspi.c drv_sys.c drv_jpegcodec.c drv_etimer_capture.c drv_timer.c drv_softi2c.c drv_usbd.c drv_crypto.c drv_usbhost.c drv_gpio.c drv_pwm.c drv_wdt.c drv_emac.c drv_vpost.c drv_i2c.c drv_2dge.c drv_scuart.c drv_uart.c drv_sdh.c
  group Fal
    rt-thread/components/fal/src/: fal.c fal_partition.c fal_rtt.c fal_flash.c
    rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Libraries
    libraries/n9h30/Driver/Source/: nu_usbd.c nu_wdt.c nu_fmi.c nu_wwdt.c nu_sys.c nu_pwm.c nu_spi.c nu_uart.c nu_emac.c nu_sdh.c nu_timer.c nu_lcd.c nu_can.c nu_etimer.c nu_crypto.c nu_rtc.c nu_i2s.c nu_gpio.c nu_scuart.c nu_cap.c
  group LVGL
    packages/LVGL-v8.3.5/src/draw/nxp/pxp/: lv_gpu_nxp_pxp_osa.c lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c
    packages/LVGL-v8.3.5/src/draw/: lv_draw.c lv_draw_transform.c lv_draw_arc.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_decoder.c lv_draw_label.c lv_draw_img.c lv_img_cache.c lv_draw_line.c lv_draw_layer.c lv_draw_mask.c
    packages/LVGL-v8.3.5/src/hal/: lv_hal_tick.c lv_hal_disp.c lv_hal_indev.c
    packages/LVGL-v8.3.5/src/draw/sdl/: lv_draw_sdl_rect.c lv_draw_sdl_line.c lv_draw_sdl_utils.c lv_draw_sdl_arc.c lv_draw_sdl_mask.c lv_draw_sdl_texture_cache.c lv_draw_sdl_bg.c lv_draw_sdl_polygon.c lv_draw_sdl_stack_blur.c lv_draw_sdl.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_composite.c
    packages/LVGL-v8.3.5/demos/music/assets/: img_lv_demo_music_cover_1.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_cover_2.c img_lv_demo_music_btn_corner_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_icon_3.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_slider_knob.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_pause.c img_lv_demo_music_cover_3.c img_lv_demo_music_btn_loop.c img_lv_demo_music_wave_top.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_logo.c img_lv_demo_music_list_border_large.c img_lv_demo_music_list_border.c img_lv_demo_music_btn_play.c img_lv_demo_music_corner_right.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_wave_top_large.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_icon_4.c
    packages/LVGL-v8.3.5/src/misc/: lv_mem.c lv_tlsf.c lv_utils.c lv_txt.c lv_txt_ap.c lv_bidi.c lv_anim_timeline.c lv_style_gen.c lv_ll.c lv_templ.c lv_color.c lv_log.c lv_printf.c lv_fs.c lv_timer.c lv_anim.c lv_lru.c lv_style.c lv_math.c lv_gc.c lv_area.c lv_async.c
    packages/LVGL-v8.3.5/src/draw/sw/: lv_draw_sw_line.c lv_draw_sw_layer.c lv_draw_sw_arc.c lv_draw_sw_polygon.c lv_draw_sw_blend.c lv_draw_sw_gradient.c lv_draw_sw_rect.c lv_draw_sw_dither.c lv_draw_sw_letter.c lv_draw_sw_img.c lv_draw_sw_transform.c lv_draw_sw.c
    packages/LVGL-v8.3.5/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.5/demos/music/: lv_demo_music_list.c lv_demo_music_main.c lv_demo_music.c
    packages/LVGL-v8.3.5/src/font/: lv_font_montserrat_14.c lv_font_montserrat_46.c lv_font_montserrat_16.c lv_font_montserrat_26.c lv_font_unscii_16.c lv_font_montserrat_42.c lv_font_montserrat_8.c lv_font_montserrat_22.c lv_font_montserrat_34.c lv_font_montserrat_12_subpx.c lv_font_montserrat_28.c lv_font_simsun_16_cjk.c lv_font.c lv_font_fmt_txt.c lv_font_montserrat_18.c lv_font_unscii_8.c lv_font_montserrat_24.c lv_font_montserrat_10.c lv_font_montserrat_20.c lv_font_montserrat_36.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_44.c lv_font_montserrat_30.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_28_compressed.c lv_font_montserrat_32.c lv_font_loader.c lv_font_montserrat_12.c lv_font_montserrat_48.c
    packages/LVGL-v8.3.5/src/core/: lv_obj_draw.c lv_obj_scroll.c lv_obj_style.c lv_disp.c lv_group.c lv_obj.c lv_indev.c lv_obj_class.c lv_event.c lv_theme.c lv_refr.c lv_indev_scroll.c lv_obj_pos.c lv_obj_style_gen.c lv_obj_tree.c
    packages/LVGL-v8.3.5/src/extra/libs/fsdrv/: lv_fs_stdio.c lv_fs_fatfs.c lv_fs_posix.c lv_fs_win32.c
    packages/LVGL-v8.3.5/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.5/src/draw/nxp/vglite/: lv_draw_vglite_blend.c lv_draw_vglite_arc.c lv_draw_vglite_line.c lv_vglite_utils.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_draw_vglite.c
    packages/LVGL-v8.3.5/demos/benchmark/assets/: img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_rgb565a8.c img_benchmark_cogwheel_rgb.c
    packages/LVGL-v8.3.5/src/widgets/: lv_line.c lv_roller.c lv_canvas.c lv_table.c lv_dropdown.c lv_switch.c lv_textarea.c lv_slider.c lv_bar.c lv_checkbox.c lv_objx_templ.c lv_label.c lv_btnmatrix.c lv_btn.c lv_img.c lv_arc.c
    packages/LVGL-v8.3.5/src/extra/libs/png/: lv_png.c lodepng.c
    packages/LVGL-v8.3.5/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    packages/LVGL-v8.3.5/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.5/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.5/demos/benchmark/: lv_demo_benchmark.c
    packages/LVGL-v8.3.5/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3.5/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.5/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.5/demos/stress/: lv_demo_stress.c
    packages/LVGL-v8.3.5/src/extra/: lv_extra.c
    packages/LVGL-v8.3.5/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.5/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.5/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.5/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.5/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.5/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    packages/LVGL-v8.3.5/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.5/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.5/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.5/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.5/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.3.5/demos/widgets/: lv_demo_widgets.c
    packages/LVGL-v8.3.5/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.5/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.5/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar.c lv_calendar_header_dropdown.c
    packages/LVGL-v8.3.5/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.5/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.5/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3.5/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.5/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.5/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.5/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.5/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.5/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.5/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.5/src/extra/libs/gif/: lv_gif.c gifdec.c
    packages/LVGL-v8.3.5/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.5/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.5/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.5/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.5/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.5/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.5/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.5/src/extra/widgets/list/: lv_list.c
  group LVGL-port
    applications/lvgl/: lv_demo.c lv_gpu_n9h30_2dge.c lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.5/env_support/rt-thread/: lv_rt_thread_port.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/apps/altcp_tls/: altcp_tls_mbedtls.c altcp_tls_mbedtls_mem.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/apps/lwiperf/: lwiperf.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/apps/snmp/: snmpv3_mbedtls.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group nu_pkgs_adc_touch
    libraries/nu_packages/ADC_TOUCH/: adc_touch.c touch_sw.c touch_serial.c
  group nu_pkgs_nau8822
    libraries/nu_packages/AudioCodec/: audio_test.c acodec_nau8822.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group ramdisk
    packages/ramdisk-latest/src/: drv_ramdisk.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group UTest
    rt-thread/components/utilities/utest/: utest.c
