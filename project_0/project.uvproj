# Keil uVision project project.uvproj, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Nuvoton_ARM9_Series Nuvoton
  cpu: IRAM(0x0-0x0) CLOCK(000000000) CPUTYPE(ARM926EJ-S)
  output: rtthread
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --c99
  c include: applications;.;board;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\extension;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\arm926;rt-thread\components\drivers\audio;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\touch;rt-thread\components\drivers\include;rt-thread\components\drivers\include;libraries\n9h30\rtt_port;rt-thread\components\fal\inc;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\finsh;.;rt-thread\include;libraries\n9h30\Driver\Include;packages\LVGL-v8.2.0\src;packages\LVGL-v8.2.0\src\core;packages\LVGL-v8.2.0\src\draw;packages\LVGL-v8.2.0\src\extra;packages\LVGL-v8.2.0\src\font;packages\LVGL-v8.2.0\src\gpu;packages\LVGL-v8.2.0\src\hal;packages\LVGL-v8.2.0\src\misc;packages\LVGL-v8.2.0\src\widgets;packages\LVGL-v8.2.0\src\draw\nxp_pxp;packages\LVGL-v8.2.0\src\draw\nxp_vglite;packages\LVGL-v8.2.0\src\draw\sdl;packages\LVGL-v8.2.0\src\draw\stm32_dma2d;packages\LVGL-v8.2.0\src\draw\sw;packages\LVGL-v8.2.0\src\extra\layouts;packages\LVGL-v8.2.0\src\extra\libs;packages\LVGL-v8.2.0\src\extra\others;packages\LVGL-v8.2.0\src\extra\themes;packages\LVGL-v8.2.0\src\extra\widgets;packages\LVGL-v8.2.0\src\extra\layouts\flex;packages\LVGL-v8.2.0\src\extra\layouts\grid;packages\LVGL-v8.2.0\src\extra\libs\bmp;packages\LVGL-v8.2.0\src\extra\libs\ffmpeg;packages\LVGL-v8.2.0\src\extra\libs\freetype;packages\LVGL-v8.2.0\src\extra\libs\fsdrv;packages\LVGL-v8.2.0\src\extra\libs\gif;packages\LVGL-v8.2.0\src\extra\libs\png;packages\LVGL-v8.2.0\src\extra\libs\qrcode;packages\LVGL-v8.2.0\src\extra\libs\rlottie;packages\LVGL-v8.2.0\src\extra\libs\sjpg;packages\LVGL-v8.2.0\src\extra\others\gridnav;packages\LVGL-v8.2.0\src\extra\others\monkey;packages\LVGL-v8.2.0\src\extra\others\snapshot;packages\LVGL-v8.2.0\src\extra\themes\basic;packages\LVGL-v8.2.0\src\extra\themes\default;packages\LVGL-v8.2.0\src\extra\themes\mono;packages\LVGL-v8.2.0\src\extra\widgets\animimg;packages\LVGL-v8.2.0\src\extra\widgets\calendar;packages\LVGL-v8.2.0\src\extra\widgets\chart;packages\LVGL-v8.2.0\src\extra\widgets\colorwheel;packages\LVGL-v8.2.0\src\extra\widgets\imgbtn;packages\LVGL-v8.2.0\src\extra\widgets\keyboard;packages\LVGL-v8.2.0\src\extra\widgets\led;packages\LVGL-v8.2.0\src\extra\widgets\list;packages\LVGL-v8.2.0\src\extra\widgets\menu;packages\LVGL-v8.2.0\src\extra\widgets\meter;packages\LVGL-v8.2.0\src\extra\widgets\msgbox;packages\LVGL-v8.2.0\src\extra\widgets\span;packages\LVGL-v8.2.0\src\extra\widgets\spinbox;packages\LVGL-v8.2.0\src\extra\widgets\spinner;packages\LVGL-v8.2.0\src\extra\widgets\tabview;packages\LVGL-v8.2.0\src\extra\widgets\tileview;packages\LVGL-v8.2.0\src\extra\widgets\win;packages\LVGL-v8.2.0\demos;packages\LVGL-v8.2.0\demos\benchmark;packages\LVGL-v8.2.0\demos\keypad_encoder;packages\LVGL-v8.2.0\demos\music;packages\LVGL-v8.2.0\demos\stress;packages\LVGL-v8.2.0\demos\widgets;packages\LVGL-v8.2.0\demos\benchmark\assets;packages\LVGL-v8.2.0\demos\music\assets;packages\LVGL-v8.2.0\demos\stress\assets;packages\LVGL-v8.2.0\demos\widgets\assets;applications\lvgl;packages\LVGL-v8.2.0\env_support\rt-thread;rt-thread\components\net\lwip\lwip-2.0.3\src\include;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;rt-thread\components\net\lwip\port;libraries\n9h30\rtt_port\fminand;libraries\n9h30\rtt_port\fminand\include;libraries\n9h30\UsbHostLib\inc;libraries\nu_packages\ADC_TOUCH;libraries\nu_packages\AudioCodec;libraries\nu_packages\TPC;libraries\nu_packages\NuUtils\inc;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;packages\ramdisk-latest\inc;rt-thread\components\drivers\usb\usbdevice;rt-thread\components\drivers\usb\usbhost;rt-thread\components\drivers\usb\usbhost\class;rt-thread\components\drivers\usb\usbhost\core;rt-thread\components\drivers\usb\usbhost\include;rt-thread\components\drivers\include;rt-thread\components\net\netdev\include;rt-thread\components\net\sal\include;rt-thread\components\net\sal\include\socket;rt-thread\components\net\sal\impl;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\net\sal\include\socket\sys_socket;rt-thread\components\utilities\utest;packages\yaffs2-latest\yaffs;packages\yaffs2-latest\yaffs\direct
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: .\linking_scripts\n9h30.sct
  group Applications
    applications/: mnt.c main.c
  group board
    board/: board_dev.c nu_pin_init.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
  group CPU
    rt-thread/libcpu/arm/common/: showmem.c div0.c backtrace.c
    rt-thread/libcpu/arm/arm926/: machine.c trap.c start_rvds.S context_rvds.S stack.c mmu.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/audio/: audio.c audio_pipe.c
    rt-thread/components/drivers/can/: can.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/ipc/: ringblk_buf.c workqueue.c waitqueue.c pipe.c dataqueue.c ringbuffer.c completion.c
    rt-thread/components/drivers/misc/: adc.c rt_drv_pwm.c pin.c rt_inputcapture.c
    rt-thread/components/drivers/mtd/: mtd_nand.c
    rt-thread/components/drivers/rtc/: rtc.c alarm.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_sfud.c
    rt-thread/components/drivers/touch/: touch.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    libraries/n9h30/rtt_port/: drv_scuart.c drv_common.c drv_i2c.c drv_emac.c drv_softi2c.c drv_systick.c drv_pwm.c drv_sys.c drv_crypto.c drv_timer.c drv_qspi.c drv_sdh.c drv_adc.c drv_ge2d.c drv_etimer_capture.c drv_i2s.c drv_rtc.c drv_vpost.c drv_etimer.c drv_can.c drv_uart.c drv_usbd.c drv_jpegcodec.c drv_gpio.c drv_wdt.c drv_usbhost.c
  group Fal
    rt-thread/components/fal/src/: fal.c fal_rtt.c fal_flash.c fal_partition.c
    rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: ffunicode.c ff.c dfs_elm.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    rt-thread/src/: scheduler.c components.c signal.c mempool.c device.c object.c ipc.c mem.c thread.c irq.c kservice.c idle.c timer.c memheap.c clock.c
  group Libraries
    libraries/n9h30/Driver/Source/: nu_can.c nu_usbd.c nu_pwm.c nu_gpio.c nu_wdt.c nu_wwdt.c nu_cap.c nu_spi.c nu_crypto.c nu_scuart.c nu_emac.c nu_rtc.c nu_sys.c nu_uart.c nu_i2s.c nu_etimer.c nu_timer.c nu_lcd.c nu_sdh.c nu_fmi.c
  group LVGL
    packages/LVGL-v8.2.0/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.2.0/demos/music/assets/: img_lv_demo_music_btn_prev_large.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_logo.c img_lv_demo_music_corner_left.c img_lv_demo_music_list_border_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_slider_knob.c img_lv_demo_music_btn_pause.c img_lv_demo_music_corner_right.c img_lv_demo_music_btn_prev.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_wave_top_large.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_corner_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_btn_next.c img_lv_demo_music_icon_4.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_list_border.c img_lv_demo_music_cover_3.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_cover_2.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_icon_1.c img_lv_demo_music_corner_right_large.c
    packages/LVGL-v8.2.0/src/misc/: lv_mem.c lv_async.c lv_log.c lv_ll.c lv_area.c lv_math.c lv_bidi.c lv_gc.c lv_timer.c lv_lru.c lv_utils.c lv_txt_ap.c lv_anim.c lv_anim_timeline.c lv_style_gen.c lv_color.c lv_tlsf.c lv_printf.c lv_txt.c lv_fs.c lv_templ.c lv_style.c
    packages/LVGL-v8.2.0/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-v8.2.0/demos/benchmark/assets/: img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_argb.c lv_font_bechmark_montserrat_28_compr_az.c.c img_benchmark_cogwheel_indexed16.c lv_font_bechmark_montserrat_12_compr_az.c.c img_benchmark_cogwheel_alpha16.c lv_font_bechmark_montserrat_16_compr_az.c.c img_benchmark_cogwheel_chroma_keyed.c
    packages/LVGL-v8.2.0/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.2.0/demos/stress/: lv_demo_stress.c
    packages/LVGL-v8.2.0/src/widgets/: lv_btn.c lv_slider.c lv_arc.c lv_btnmatrix.c lv_canvas.c lv_objx_templ.c lv_roller.c lv_switch.c lv_textarea.c lv_dropdown.c lv_label.c lv_img.c lv_line.c lv_table.c lv_checkbox.c lv_bar.c
    packages/LVGL-v8.2.0/src/font/: lv_font_montserrat_12_subpx.c lv_font_montserrat_42.c lv_font_montserrat_14.c lv_font_montserrat_24.c lv_font_montserrat_20.c lv_font_montserrat_46.c lv_font_montserrat_16.c lv_font_montserrat_28.c lv_font_montserrat_30.c lv_font_montserrat_48.c lv_font_montserrat_36.c lv_font_montserrat_8.c lv_font.c lv_font_montserrat_22.c lv_font_simsun_16_cjk.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_12.c lv_font_unscii_16.c lv_font_montserrat_38.c lv_font_unscii_8.c lv_font_fmt_txt.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_44.c lv_font_montserrat_26.c lv_font_loader.c lv_font_montserrat_40.c lv_font_montserrat_10.c lv_font_montserrat_28_compressed.c lv_font_montserrat_18.c
    packages/LVGL-v8.2.0/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/LVGL-v8.2.0/src/draw/sw/: lv_draw_sw_img.c lv_draw_sw_blend.c lv_draw_sw_polygon.c lv_draw_sw_line.c lv_draw_sw_arc.c lv_draw_sw_letter.c lv_draw_sw_gradient.c lv_draw_sw.c lv_draw_sw_dither.c lv_draw_sw_rect.c
    packages/LVGL-v8.2.0/src/draw/sdl/: lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_img.c lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_composite.c lv_draw_sdl_bg.c lv_draw_sdl_label.c lv_draw_sdl_stack_blur.c lv_draw_sdl_rect.c lv_draw_sdl_polygon.c lv_draw_sdl_utils.c lv_draw_sdl_texture_cache.c
    packages/LVGL-v8.2.0/src/core/: lv_refr.c lv_obj_scroll.c lv_event.c lv_obj_class.c lv_obj_tree.c lv_obj_pos.c lv_indev.c lv_disp.c lv_indev_scroll.c lv_theme.c lv_obj_style.c lv_obj_style_gen.c lv_obj_draw.c lv_group.c lv_obj.c
    packages/LVGL-v8.2.0/demos/stress/assets/: lv_font_montserrat_28_compr_az.c lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c
    packages/LVGL-v8.2.0/src/hal/: lv_hal_indev.c lv_hal_disp.c lv_hal_tick.c
    packages/LVGL-v8.2.0/src/draw/: lv_draw.c lv_img_cache.c lv_draw_mask.c lv_draw_img.c lv_draw_rect.c lv_img_buf.c lv_draw_triangle.c lv_draw_line.c lv_draw_arc.c lv_draw_label.c lv_img_decoder.c
    packages/LVGL-v8.2.0/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.2.0/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.2.0/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    packages/LVGL-v8.2.0/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.2.0/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.2.0/demos/widgets/assets/: img_demo_widgets_avatar.c img_lvgl_logo.c img_clothes.c
    packages/LVGL-v8.2.0/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.2.0/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.2.0/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.2.0/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.2.0/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.2.0/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.2.0/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.2.0/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.2.0/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.2.0/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.2.0/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    packages/LVGL-v8.2.0/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_stdio.c lv_fs_posix.c lv_fs_win32.c
    packages/LVGL-v8.2.0/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.2.0/src/extra/: lv_extra.c
    packages/LVGL-v8.2.0/demos/widgets/: lv_demo_widgets.c
    packages/LVGL-v8.2.0/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    packages/LVGL-v8.2.0/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.2.0/demos/music/: lv_demo_music_main.c lv_demo_music_list.c lv_demo_music.c
    packages/LVGL-v8.2.0/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.2.0/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.2.0/demos/benchmark/: lv_demo_benchmark.c
    packages/LVGL-v8.2.0/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.2.0/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.2.0/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.2.0/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.2.0/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.2.0/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.2.0/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.2.0/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.2.0/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.2.0/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.2.0/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    packages/LVGL-v8.2.0/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group LVGL-port
    applications/lvgl/: lv_gpu_n9h30_ge2d.c lv_port_disp.c lv_demo.c lv_port_indev.c
    packages/LVGL-v8.2.0/env_support/rt-thread/: lv_rt_thread_port.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: ip.c netif.c sys.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c tcp_in.c dns.c timeouts.c udp.c pbuf.c def.c tcp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group MTDDrv
    libraries/n9h30/rtt_port/fminand/: nu_fminand.c mtdcore.c nand_base.c nand_util.c drv_fminand.c ctype.c nand_ids.c nand_bbt.c
  group n9h30_usbhostlib
    libraries/n9h30/UsbHostLib/src/: ehci_iso.c mem_alloc.c usb_core.c support.c ohci.c ehci.c
  group nu_pkgs_adc_touch
    libraries/nu_packages/ADC_TOUCH/: adc_touch.c touch_sw.c
  group nu_pkgs_nau8822
    libraries/nu_packages/AudioCodec/: audio_test.c acodec_nau8822.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: select.c poll.c
  group ramdisk
    packages/ramdisk-latest/src/: drv_ramdisk.c
  group rt_usbd
    rt-thread/components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    rt-thread/components/drivers/usb/usbdevice/class/: mstorage.c cdc_vcom.c
  group rt_usbh
    rt-thread/components/drivers/usb/usbhost/class/: mass.c udisk.c
    rt-thread/components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev_ipaddr.c netdev.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/src/: sal_socket.c
    rt-thread/components/net/sal/socket/: net_sockets.c net_netdb.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
  group UTest
    rt-thread/components/utilities/utest/: utest.c
  group yaffs
    packages/yaffs2-latest/yaffs/direct/: yaffs_hweight.c yaffs_attribs.c yaffs_error.c yaffsfs.c
    packages/yaffs2-latest/: dfs_yaffs_s.c yaffs_osglue.c yaffs_flashif.c
    packages/yaffs2-latest/yaffs/: yaffs_verify.c yaffs_guts.c yaffs_endian.c yaffs_yaffs2.c yaffs_packedtags2.c yaffs_checkptrw.c yaffs_tagscompat.c yaffs_nand.c yaffs_cache.c yaffs_ecc.c yaffs_bitmap.c yaffs_packedtags1.c yaffs_nameval.c yaffs_tagsmarshall.c yaffs_allocator.c yaffs_yaffs1.c yaffs_summary.c
